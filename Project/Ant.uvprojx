# Keil uVision project Ant.uvprojx, settings and files
target Ant (ARM-ADS)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ant +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10_HD,USE_STDPERIPH_DRIVER
  c include: ..\Commen\inc;..\Device\Interface;..\Init;..\Tools\Inc;..\File;..\File\FAT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../Application/User/: main.c
  group Interface
    ../Device/Interface/: Interface.h Typedefine.h Config.h
  group Implements
    ../Device/Implement/: Delay.c LED.c Uart.c SPI.c MicroSD.c W25Q128.c LCD.c Key.c VS1053B.c
  group Init
    ../Init/: Init.c Init.h startup_stm32f10x_hd.s
  group Commen
    ../Commen/src/: misc.c stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_rtc.c core_cm3.c stm32f10x_it.c stm32f10x_gpio.c stm32f10x_tim.c sys.c system_stm32f10x.c stm32f10x_usart.c stm32f10x_spi.c
  group Tools
    ../Tools/Src/: StringOperation.c FrameBox.c Font.c malloc.c
  group File
    ../File/FAT/: diskio.c ff.c cc936.c exfuns.c fattester.c
